# Autodesk Inventor part: 010-9440-7326
## iProperties
Created: 2015-03
Part Number: 010-9440-7326
Document SubType Name: Modeling
Designer: elite
Density: 1 g/cm^3
Author: elite
